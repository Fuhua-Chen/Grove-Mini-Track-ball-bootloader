# Keil uVision project Grove - Mini Track Ball_Bootloader.uvprojx, settings and files
target Grove - Mini Track ball Bootloader (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: GroveMiniTrackBallBootloader +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\Output\GroveMiniTrackBallBootloader.bin .\Output\GroveMiniTrackBallBootloader.axf
  c flags: Optim=1
  c include: .\User;.\RTE;.\RTE\Device;.\RTE\Device\STM32F103C8
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: init.c software_uart.c main.c delay.c common.c download.c upload.c ymodem.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0
